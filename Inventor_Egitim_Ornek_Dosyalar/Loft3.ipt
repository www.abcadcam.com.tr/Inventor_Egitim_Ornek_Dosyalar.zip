# Autodesk Inventor part: Loft3
## iProperties
Created: 2005-07
Part Number: Loft3
Document SubType Name: Modeling
Designer: haughec
Density: 1 g/cm^3
Author: haughec
