# Autodesk Inventor part: Parametrik_Parca
## iProperties
Created: 2006-01
Part Number: Parametrik_Parca
Document SubType Name: Modeling
Designer: Ron
Density: 1 g/cm^3
Author: Ron
