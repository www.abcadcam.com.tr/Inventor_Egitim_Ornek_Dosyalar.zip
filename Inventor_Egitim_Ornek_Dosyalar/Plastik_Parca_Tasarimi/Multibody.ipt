# Autodesk Inventor part: Multibody
## iProperties
Created: 2008-12
Part Number: Multibody
Document SubType Name: Modeling
Designer: Designer
Density: 1 g/cm^3
Author: Designer
