# Autodesk Inventor assembly: Crown_Assembly
## iProperties
Created: 2005-03
Part Number: Crown_Assembly
Document SubType Name: Assembly
Designer: Admin
Author: Admin
