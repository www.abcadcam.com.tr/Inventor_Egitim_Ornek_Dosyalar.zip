# Autodesk Inventor assembly: Forks
## iProperties
Created: 2005-03
Part Number: Forks
Document SubType Name: Weldment
Designer: Admin
Weld Material: Welded Aluminum-6061
Author: Admin
