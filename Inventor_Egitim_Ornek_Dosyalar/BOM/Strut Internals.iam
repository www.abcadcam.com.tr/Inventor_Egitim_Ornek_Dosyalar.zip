# Autodesk Inventor assembly: Strut Internals
## iProperties
Created: 2005-03
Part Number: Strut Internals
Document SubType Name: Assembly
Designer: Admin
Stock Number: Strut Internals
Author: Admin
