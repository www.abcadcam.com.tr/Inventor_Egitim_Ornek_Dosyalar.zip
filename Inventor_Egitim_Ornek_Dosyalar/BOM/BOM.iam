# Autodesk Inventor assembly: BOM
## iProperties
Created: 2005-03
Part Number: BOM
Document SubType Name: Assembly
Designer: Admin
Author: Admin
