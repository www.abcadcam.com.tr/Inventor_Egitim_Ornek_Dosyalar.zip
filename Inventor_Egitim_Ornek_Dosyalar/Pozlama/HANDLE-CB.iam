# Autodesk Inventor assembly: HANDLE-CB
## iProperties
Created: 2006-07
Part Number: HANDLE-CB
Document SubType Name: Assembly
Designer: rollin42
Stock Number: HANDLE-CB
Author: rollin42
