# Autodesk Inventor assembly: HANDLE
## iProperties
Created: 2006-07
Part Number: HANDLE
Document SubType Name: Assembly
Designer: rollin42
Author: rollin42
