# Autodesk Inventor part: Karmasik_Supurme
## iProperties
Created: 2005-09
Part Number: Karmasik_Supurme
Document SubType Name: Modeling
Designer: haughec
Density: 1 g/cm^3
Author: haughec
