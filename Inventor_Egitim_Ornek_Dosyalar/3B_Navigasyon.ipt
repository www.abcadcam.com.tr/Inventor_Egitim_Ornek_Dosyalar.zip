# Autodesk Inventor part: 3B_Navigasyon
## iProperties
Created: 2007-02
Part Number: 3B_Navigasyon
Document SubType Name: Modeling
Designer: floress
Density: 1 g/cm^3
