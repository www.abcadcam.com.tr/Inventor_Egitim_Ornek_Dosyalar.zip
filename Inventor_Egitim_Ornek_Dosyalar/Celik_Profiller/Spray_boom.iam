# Autodesk Inventor assembly: Spray_boom
## iProperties
Created: 2007-04
Part Number: Spray_boom
Document SubType Name: Assembly
Designer: Admin
Author: Admin
