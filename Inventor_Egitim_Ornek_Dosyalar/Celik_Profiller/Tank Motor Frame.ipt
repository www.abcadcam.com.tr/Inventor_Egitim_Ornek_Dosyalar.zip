# Autodesk Inventor part: Tank Motor Frame
## iProperties
Created: 2007-04
Part Number: Tank Motor Frame
Document SubType Name: Modeling
Designer: Admin
Density: 1 g/cm^3
Author: Admin
