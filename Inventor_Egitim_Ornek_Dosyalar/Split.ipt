# Autodesk Inventor part: Split
## iProperties
Created: 2009-12
Part Number: Split
Document SubType Name: Modeling
Designer: bulent
Density: 1 g/cm^3
Author: bulent
## Feature names
1. Extrusion1
