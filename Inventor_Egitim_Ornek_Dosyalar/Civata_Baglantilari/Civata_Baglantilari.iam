# Autodesk Inventor assembly: Civata_Baglantilari
## iProperties
Company: Autodes, Inc
Created: 2005-03
Part Number: Civata_Baglantilari
Document SubType Name: Assembly
Author: Admin
