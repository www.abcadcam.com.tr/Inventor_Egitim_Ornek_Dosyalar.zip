# Autodesk Inventor assembly: MountingPlate
## iProperties
Company: Autodes, Inc
Created: 2005-03
Part Number: MountingPlate
Document SubType Name: Weldment
Stock Number: MountingPlate
Author: Admin
