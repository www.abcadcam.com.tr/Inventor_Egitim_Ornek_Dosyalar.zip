# Autodesk Inventor assembly: Standart_Parcalar_Kutuphanesi
## iProperties
Created: 2005-03
Part Number: Standart_Parcalar_Kutuphanesi
Document SubType Name: Assembly
Designer: Admin
Author: Admin
